# Build target binutils without gprofng
EXTRA_OECONF:append = " --disable-gprofng"
