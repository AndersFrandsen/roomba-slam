require suitesparse-blas.inc
