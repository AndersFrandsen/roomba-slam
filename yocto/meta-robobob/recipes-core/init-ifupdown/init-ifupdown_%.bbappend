# Override poky's default /etc/network/interfaces
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
